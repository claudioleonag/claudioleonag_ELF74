# IAR project Projeto_Final.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C1292NCPDT TexasInstruments TM4C1292NCPDT
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: TX_ENABLE_IAR_LIBRARY_SUPPORT; ewarm; PART_TM4C1294NCPDT; TARGET_IS_TM4C129_RA2
  ICCARM.CCIncludePath2: C:\Users\claud\OneDrive\UTFPR\Semestre 2 - 2021\Sistemas Embarcados\Labs\claudioleonag_ELF74\threadx\common\inc; C:\Users\claud\OneDrive\UTFPR\Semestre 2 - 2021\Sistemas Embarcados\Labs\claudioleonag_ELF74\threadx\ports\cortex_m4\iar\inc; C:\Users\claud\OneDrive\UTFPR\Semestre 2 - 2021\Sistemas Embarcados\Labs\claudioleonag_ELF74\TivaWare
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Projeto_Final.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group include
    include/: sample_threadx.h uart.h
  group library
    library/: driverlib.a tx.a
  group source
    ./: main.c sample_threadx.c startup_ewarm.c uart.c
    ../Lab5/src/: tx_initialize_low_level.s

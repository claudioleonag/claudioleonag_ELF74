# IAR project Lab 2.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C1294NCPDT TexasInstruments TM4C1294NCPDT
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ewarm; PART_TM4C1294NCPDT; TARGET_IS_TM4C129_RA1
  ICCARM.CCIncludePath2: ..\..\..\..; C:\Users\claud\OneDrive\UTFPR\Semestre 2 - 2021\Sistemas Embarcados\Labs\claudioleonag_ELF74\TivaWare
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Lab 2.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: C:\Program Files\IAR Systems\Embedded Workbench 9.0\arm\config\linker\TexasInstruments\TM4C1294KC.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Library
    ../TivaWare/driverlib/ewarm/Exe/: driverlib.a
  group Source
    ./: blinky.c startup_TM4C1294.s system_TM4C1294.c

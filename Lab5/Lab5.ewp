# IAR project Lab5.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C1294NCPDT TexasInstruments TM4C1294NCPDT
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: TX_ENABLE_IAR_LIBRARY_SUPPORT
  AARM.AUserIncludes: C:\Users\claud\OneDrive\UTFPR\Semestre 2 - 2021\Sistemas Embarcados\Labs\claudioleonag_ELF74\threadx; C:\Users\claud\OneDrive\UTFPR\Semestre 2 - 2021\Sistemas Embarcados\Labs\claudioleonag_ELF74\threadx\common\inc
  OBJCOPY.OOCOutputFile: Lab5.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Library
    src/: tx.a
  group src
    src/: cstartup_M.s sample_threadx.c tx_initialize_low_level.s
